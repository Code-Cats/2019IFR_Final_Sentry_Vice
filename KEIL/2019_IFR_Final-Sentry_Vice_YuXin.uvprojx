# Keil uVision project 2019_IFR_Final-Sentry_Vice_YuXin.uvprojx, settings and files
target 2019_IFR_Final-Sentry_Vice_YuXin (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2019_IFR_Final-Sentry_Vice_YuXin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32MCU;..\STM32MCU\FWLIB\inc;..\STM32MCU\CORE;..\ROBOT\ALGO;..\ROBOT\ANALYSIS;..\ROBOT\APP;..\ROBOT\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
  group APP
    ../ROBOT/APP/: control.c delay.c sys.c
  group BSP
    ../ROBOT/BSP/: bsp.c exti_encoder.c gpio_led.c gpio_switch.c gpio_valve.c pwm.c timer.c usart2_mainboard.c
  group STM32MCU
    ../STM32MCU/: stm32f10x_it.c system_stm32f10x.c
    ../STM32MCU/CORE/: core_cm3.c startup_stm32f10x_md.s
    ../STM32MCU/FWLIB/src/: misc.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group ANALYSIS
    ../ROBOT/ANALYSIS/: base_deal.c usart2_mainboard_analysis.c
